# Keil uVision project Project.uvprojx, settings and files
target STM32746G_DISCOVERY (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G_DISCOVERY
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32756G_DISCOVERY
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32746G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STemWin/inc;../../../../../../Utilities;../../../../../../Utilities/Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_ll_fmc.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr_ex.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf.c
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Application/MDK-ARM
    ../Src/: LCDConf.c
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32746G_DISCOVERY
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_sdram.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM7_Keil.lib
  group Application/User
    ../Src/: main.c stm32f7xx_it.c BASIC_HelloWorld.c
    ./: stm32f7xx_hal_msp.c
software components: CMSIS:CORE 4.3.0
